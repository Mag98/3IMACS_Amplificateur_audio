# Repository Mag98/3IMACS_Amplificateur_audio

## KiCad design amplificateur_audio/amplificateur_audio.kicad_pcb

Parts:
C1, C3: 47u; CP_Radial_D8.0mm_P5.00mm
C2, C11: C; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C4, C6: 10u; CP_Radial_D8.0mm_P5.00mm
C5, C7, C9: 100n; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C8, C10: 470u; CP_Radial_D12.5mm_P5.00mm
D1, D2: D; D_DO-35_SOD27_P10.16mm_Horizontal
D3: D_Zener; D_DO-35_SOD27_P10.16mm_Horizontal
HS1, HS2: Heatsink; Heatsink_Fischer_SK104-STC-STIC_35x13mm_2xDrill2.5mm
J2: Conn_01x02; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J3: Conn_01x03; PhoenixContact_MSTBVA_2,5_3-G-5,08_1x03_P5.08mm_Vertical
K1: Relay_1CT; Relais_112LMH2
Q1, Q2, Q3, Q6, Q7: Q_PNP_EBC; TO-18-3
Q4, Q5, Q13: Q_NPN_EBC; TO-18-3
Q8, Q9: Q_NPN_ECB; TO-126-3_Vertical
Q10: Q_PNP_BCE; TO-220-3_Vertical
Q11: BC636; TO-126-3_Vertical
Q12: Q_NPN_BCE; TO-220-3_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R13, R14, R15, R16, R17: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R12: R; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
RV1, RV2: R_POT; Potentiometer_Bourns_3296W_Vertical
U1: Jack_Mono; Jack_35RAPC2AV

Connections:
+12V: C4.1, C5.2, C8.1, C9.1, D1.1 (K), D3.1 (K), J3.3, K1.b2, Q10.3 (E), R4.1, R7.1, R9.2, R16.1; also elsewhere on the board
-12V: C3.2, C6.2, C7.1, C10.2, C11.2, J3.1, Q12.3 (E), R2.2, R3.2, R6.2; also elsewhere on the board
GND: C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.1, C11.1, J2.1, J3.2, Q13.1 (E), R1.2, R5.1, R13.2, R14.2, R15.2, R17.2, RV2.1, U1.G; also elsewhere on the board
unnamed: C1.1, Q1.2 (B), R1.1
unnamed: C1.2, U1.T
unnamed: C2.1, Q4.3 (C), Q5.3 (C), Q8.1 (E), Q11.3 (B), R8.1
unnamed: C2.2, Q1.3 (C), Q4.2 (B), R2.1
unnamed: C3.1, D2.2 (A), R16.2
unnamed: D1.2 (A), K1.b1, Q13.3 (C)
unnamed: D2.1 (K), Q13.2 (B), R17.1
unnamed: D3.2 (A), Q3.2 (B), R5.2
unnamed: J2.2, K1.c2
unnamed: K1.c1, R11.2, R12.1, R13.1, R14.1
unnamed: Q1.1 (E), Q2.1 (E), Q3.3 (C)
unnamed: Q2.2 (B), R15.1
unnamed: Q2.3 (C), R3.1
unnamed: Q3.1 (E), R4.2
unnamed: Q4.1 (E), Q5.2 (B)
unnamed: Q5.1 (E), R6.1
unnamed: Q6.1 (E), R7.2
unnamed: Q6.2 (B), Q7.2 (B), Q7.3 (C), R10.2
unnamed: Q6.3 (C), Q8.2 (C), Q9.3 (B), RV1.1
unnamed: Q7.1 (E), R9.1
unnamed: Q8.3 (B), RV1.2
unnamed: Q9.2 (C), Q10.1 (B)
unnamed: Q9.1 (E), Q10.2 (C), R11.1
unnamed: Q11.1 (E), Q12.2 (C), R12.2
unnamed: Q11.2 (C), Q12.1 (B)
unnamed: R8.2, RV1.3
unnamed: R10.1, RV2.2, RV2.3

Notes on the sheet:
Source de courant
Alimentation

Board: 2 copper layers, 54 parts (0 on the bottom side), 30 nets.

Other parts of the board:
D4, D5: D; D_DO-35_SOD27_P10.16mm_Horizontal

Their connections:
+12V: D5.1; also elsewhere on the board
-12V: D4.2; also elsewhere on the board
GND: D4.1, D5.2; also elsewhere on the board

## Commit log

2021-03-21 ROUTAGE
2021-03-25 replaced potentiometer with wires
2021-03-25 updated sch library (added component : relais)
2021-03-25 reports and netlists
2021-03-25 update of footprint library (added : footprint of relay
2021-03-25 pcb file
2021-03-25 report
2021-04-05 correction de l'association des pin entre symbole et empreinte du relais
2021-04-05 rectification du circuit
2021-04-05 netlist
2021-04-05 erc report
2021-04-05 pcb layout v2
2021-04-05 new footprint librairies (bigger pad diameter)
2021-04-05 modif DRC
2021-04-06 correction empreinte Relais
2021-04-06 light change - schematic
2021-04-06 v3 - modif
2021-04-06 changes : relais footprint - c4 & c6 footprint
2021-04-06 v3: regroupement des composants de puissances , correction footprint relais + c4 + c6
2021-04-06 footprint CmpAmpliAudioTR.pretty (avec relais)
2021-04-06 file lib CmpAmpliAudioTR
2021-04-14 ajout pistes
2021-04-21 routage + ajout de plan de masse
2021-04-21 schematic added 2 diodes
2021-04-21 pcb layout with added diodes
2021-04-22 pcb modifie sans vias
2021-04-22 ajout de plan de masse couche front
2021-04-22 ajout de plan de masse back + vias entre les plans de masses
2021-04-22 updated DRC
2021-04-23 pcb ampli audio v3
2021-04-23 ampli audio v4 updated DRC
2021-04-23 correction du plan de masse
